# Repository AdrienWarnet/Shield-E-R-n-1

File README.md:

# Shield-E-R-n-1
Réalisation d'un Shield Arduino, permettant de contrôler un ventilateur ou une lampe.
Le programme arduino, et les schémas kikad de notre carte

## KiCad design Shield arduino/Shield_AWED 1/Shield_AWED.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 4 parts (0 on the bottom side), 3 nets, no tracks yet.

Parts:
P1, P4: CONN_01X08; IUT-SIL-8
P2: CONN_01X06; IUT-SIL-6
P3: CONN_01X10; IUT-SIL-10

Connections:
/AD4/SDA: P2.5, P3.9
/AD5/SCL: P2.6, P3.10
GND: P1.2, P1.3, P3.7

## KiCad design Shield arduino/Shield_AWED/Shield_AWED.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 27 parts (0 on the bottom side), 21 nets.

Parts:
C1, C2: C; C_0805
D1, D2, D3: LED; LED_0805
D4: D; MiniMELF_Handsoldering
GS1: GS2; finger
K1: RELAY_1RT; SONGLE_RELAY
P1, P4: CONN_01X08; IUT-SIL-8
P2: CONN_01X06; IUT-SIL-6
P3: CONN_01X10; IUT-SIL-10
P5: CONN_01X03; IUT-bornier3
Q1: BC847; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8: R; R_0805
RV1: POT; POTSMD
SW1, SW2: SW_PUSH; IUT-PUSH_SW-6x6-5x10-SMD
U1: TSL252; IUT-SIL-3
VR1: VR; R_0603

Connections:
+5V: D4.1, K1.1, P1.4, R1.1, R3.1, R6.1, R8.1, RV1.1, U1.2
/AD0: P2.1, RV1.2
/AD1: P2.2, R2.2, U1.3
/AD2: C1.1, P2.3, R2.1
/AD3: C2.1, GS1.1, P2.4, R8.2, VR1.1
/AD4/SDA: P2.5, P3.9
/AD5/SCL: P2.6, P3.10
/IO2: P4.3, R4.1
/IO3: P4.4, R7.1
/IO5: P4.6, R3.2, SW2.1
/IO6: P4.7, R1.2, SW1.1
/IO7: P4.8, R5.1
/com1: K1.3, P5.2
/nc1: K1.4, P5.1
/no1: K1.5, P5.3
GND: C1.2, C2.2, D1.1, D3.1, GS1.2, P1.2, P1.3, P3.7, Q1.2, RV1.3, SW1.2, SW2.2, U1.1, VR1.2
unnamed: D1.2, R4.2
unnamed: D2.1, D4.2, K1.2, Q1.3
unnamed: D2.2, R6.2
unnamed: D3.2, R7.2
unnamed: Q1.1, R5.2
